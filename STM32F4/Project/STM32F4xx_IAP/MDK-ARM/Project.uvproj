# Keil uVision project Project.uvproj, settings and files
target STM32F4_BOOT_RAM (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: BOOT_RAM +hex
  AfterMake: ..\hex2bin.exe  BOOT_RAM\BOOT_RAM.hex
  AfterMake: ..\buildComplete.bat
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STM324xG_EVAL, STM32F4XX, USE_STDPERIPH_DRIVER,VECT_TAB_SRAM
  c include: ..\inc;..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM3240_41_G_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x4000
  memory RVCT9: RAM 0x20004000 size 0x1c000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ../src/: common.c flash_if.c main.c menu.c stm32f4xx_it.c ymodem.c
  group BoardSupportPackage
    ../../../Utilities/STM32_EVAL/STM3240_41_G_EVAL/: stm324xg_eval.c
  group STM32F4xx_StdPeriph_Driver
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CMSIS
    ../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group MDK-ARM
    ../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
target STM32F4_BOOT_ROM (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VG STMicroelectronics
  cpu: as above
  output: BOOT_ROM +hex
  AfterMake: ..\hex2bin.exe  BOOT_ROM\BOOT_ROM.hex
  AfterMake: ..\buildBOOTROM.bat
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STM324xG_EVAL, STM32F4XX, USE_STDPERIPH_DRIVER,RUN_FROM_8M
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target STM32F4_MAIN_DBG (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407VG STMicroelectronics
  cpu: as above
  output: MAIN_DBG +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STM324xG_EVAL, STM32F4XX, USE_STDPERIPH_DRIVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target STM32F4_MAIN_ROM (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VG STMicroelectronics
  cpu: as above
  output: MAIN_ROM +hex
  AfterMake: ../hex2bin.exe  MAIN_ROM/MAIN_ROM.hex
  AfterMake: ..\buildMAINROM.bat
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STM324xG_EVAL, STM32F4XX, USE_STDPERIPH_DRIVER,RUN_FROM_8M_PLUS
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
